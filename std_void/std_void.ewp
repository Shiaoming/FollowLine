# IAR project std_void.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xE ST STM32F103xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: VECT_TAB_RAM
  ICCARM.CCIncludePath2: ..\library\inc; app
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: std_void.srec
  ILINK.IlinkOutputFile: std_void.out
  ILINK.IlinkIcfFile: config\stm32f10x_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration flash (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F103x8 ST STM32F103x8
  OBJCOPY.OOCOutputFile: std_void.hex
  ILINK.IlinkIcfFile: config\stm32f10x_flash.icf
  group (top)
    app/: includes.h main.c main.h sys_ini.c sys_ini.h systime.c systime.h
  group driver
    app/: adc.c adc.h can.c can.h imprecisedelay.c imprecisedelay.h led.c led.h usart.c usart.h
  group lib
    app/: stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h stm32f10x_vector.c
  group lib_in
    ../library/src/: stm32f10x_adc.c stm32f10x_can.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_rcc.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c
  group lib_out
    ../library/src/: stm32f10x_bkp.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_wwdg.c
