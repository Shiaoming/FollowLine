<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>flash</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>driver</name>
    <file>
      <name>$PROJ_DIR$\app\adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\app\adc.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\app\can.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\app\can.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\app\imprecisedelay.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\app\imprecisedelay.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\app\led.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\app\led.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\app\usart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\app\usart.h</name>
    </file>
  </group>
  <group>
    <name>lib</name>
    <file>
      <name>$PROJ_DIR$\app\stm32f10x_conf.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\app\stm32f10x_it.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\app\stm32f10x_it.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\app\stm32f10x_vector.c</name>
    </file>
  </group>
  <group>
    <name>lib_in</name>
    <file>
      <name>$PROJ_DIR$\..\library\src\stm32f10x_adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\library\src\stm32f10x_can.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\library\src\stm32f10x_dma.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\library\src\stm32f10x_flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\library\src\stm32f10x_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\library\src\stm32f10x_lib.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\library\src\stm32f10x_nvic.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\library\src\stm32f10x_rcc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\library\src\stm32f10x_systick.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\library\src\stm32f10x_tim.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\library\src\stm32f10x_usart.c</name>
    </file>
  </group>
  <group>
    <name>lib_out</name>
    <file>
      <name>$PROJ_DIR$\..\library\src\stm32f10x_bkp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\library\src\stm32f10x_crc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\library\src\stm32f10x_dac.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\library\src\stm32f10x_dbgmcu.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\library\src\stm32f10x_exti.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\library\src\stm32f10x_fsmc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\library\src\stm32f10x_i2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\library\src\stm32f10x_iwdg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\library\src\stm32f10x_pwr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\library\src\stm32f10x_rtc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\library\src\stm32f10x_sdio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\library\src\stm32f10x_spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\library\src\stm32f10x_wwdg.c</name>
    </file>
  </group>
  <file>
    <name>$PROJ_DIR$\app\includes.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\app\main.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\app\main.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\app\sys_ini.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\app\sys_ini.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\app\systime.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\app\systime.h</name>
  </file>
</project>


